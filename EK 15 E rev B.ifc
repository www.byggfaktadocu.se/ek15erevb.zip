Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2023-01-18T13:58:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 24.50.40000.0000 - Exporter 20.0.0.364 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 18 13:58:18 2023 * Host: KONSTRUKTION44 * Database: C:\Users\AndersAb\AppData\Local\Temp\207cbcd9-9276-4d96-b119-e84011551dde\f54a7fd7-460f-4986-89cc-8b5ddd0f468f\ifc * Database version: 5507 * Database creation date: Wed Jan 18 13:58:13 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 18 13:58:13 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 18 13:58:13 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Elpanna / Electrical boiler, Family1:Elpanna / Electrical boiler:205342
In: Level 1
Type - Material: Ral 9010 glans 80_3, Ral 9010 glans 80_1, Black (Casting 2), Smooth - White_3, Plastic (White)_2, Metal-Steel_1, Steel, FZB
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connector_1_Diameter: 31.7 mm; Connector_2_Diameter: 31.7 mm
Type - Identity Data - Description: Elpanna / Electrical boiler; Manufacturer: Värmebaronen AB; Model: EK 15 E; Type Name: Elpanna / Electrical boiler; URL: www.varmebaronen.se
Type - Other - Category: Generic Models; Family Name: Family1
Type - Pset_BuildingElementProxyCommon - Reference: Elpanna / Electrical boiler
Type - Pset_ManufacturerTypeInformation - Manufacturer: Värmebaronen AB
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: Elpanna / Electrical boiler
Pset_BuildingElementProxyCommon - sets with these values: 2
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 0.655586 m2; Volume: 0.000592389 m3
Other - Family: Family1: Elpanna / Electrical boiler; Family and Type: Family1: Elpanna / Electrical boiler; Type: Family1: Elpanna / Electrical boiler; Type Id: Family1: Elpanna / Electrical boiler
Phasing - Phase Created: New Construction

# IfcDistributionPort (6)
Description: Flow
Name | FlowDirection
4 x Port_205342 | SOURCEANDSINK
Port_205342 | SOURCE
Port_205342 | SINK
